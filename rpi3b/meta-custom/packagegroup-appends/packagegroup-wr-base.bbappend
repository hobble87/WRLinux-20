RDEPENDS_${PN}_remove = "rsyslog"
RDEPENDS_${PN}-discrete-tools_remove = "ifupdown"
RDEPENDS_${PN}-net_remove = "dhcpcd"
RDEPENDS_${PN}-base-utils_remove = "dhcpcd"
