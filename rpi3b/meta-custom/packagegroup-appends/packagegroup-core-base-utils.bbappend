RDEPENDS_${PN}_remove = "ifupdown dhcpcd"

