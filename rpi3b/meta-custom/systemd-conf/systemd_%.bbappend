FILESEXTRAPATHS_prepend := "${THISDIR}/files:"


PACKAGECONFIG_append = " networkd resolved"
